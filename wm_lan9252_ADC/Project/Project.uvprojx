# Keil uVision project Project.uvprojx, settings and files
target STM32F40_41xxx (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F407ZE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F40_41xxx +hex
  c flags: Optim=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx
  c misc: --C99
  c include: ..\;..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\Ethercat\Inc;..\Ethercat\src;..\User;..\Libraries\CMSIS\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
  group StartUp
    ../Libraries/CMSIS/Device/ST/STM32F4xx/Source/: startup_stm32f40_41xxx.s
  group STM32F4xx_StdPeriph_Driver
    ../User/: system_stm32f4xx.c
    ../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_spi.c
  group User
    ../User/: bsp.c stm32f405hw.c stm32f405appl.c
  group EtherCatStack
    ../Ethercat/src/: coeappl.c ecatappl.c aoeappl.c ecataoe.c foeappl.c ecatcoe.c bootmode.c diag.c ecatfoe.c ecateoe.c ecatslv.c ecatsoe.c emcy.c eoeappl.c mailbox.c objdef.c sdoserv.c
  group Doc
    ../User/: readme.txt
